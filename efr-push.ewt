<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>drivers</name>
    <group>
      <name>efr32xg13</name>
      <file>
        <name>$PROJ_DIR$\source\custom_app\drivers\efr32xg13\exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\custom_app\drivers\efr32xg13\exti.c.bak</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\custom_app\drivers\efr32xg13\io.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\custom_app\drivers\efr32xg13\io.c.bak</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\custom_app\drivers\efr32xg13\led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\custom_app\drivers\efr32xg13\LICENSE.txt</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\custom_app\drivers\efr32xg13\makefile</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\source\custom_app\drivers\io.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\drivers\led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\drivers\LICENSE.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\drivers\makefile</name>
    </file>
  </group>
  <group>
    <name>meter</name>
    <file>
      <name>$PROJ_DIR$\source\custom_app\app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\board\brd4158a\board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\DCUPush.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\DLTProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\DLTProtocol.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\gateway-passwords.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\makefile</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\MeterProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\meterprotocol.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\MeterPush.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\persistent.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\persistent.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\uartdlt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\uartdlt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\Untitled1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\Untitled2</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\utils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\utils.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\meter\WaterCalc.h</name>
    </file>
  </group>
  <group>
    <name>sap</name>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\attribute_frames.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\csap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\csap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\csap_frames.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\dsap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\dsap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\dsap_frames.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\function_codes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\function_codes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\LICENSE.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\lock_bits.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\lock_bits.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\msap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\msap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\msap_frames.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\multicast.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\multicast.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\persistent.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\persistent.c.bak</name>
    </file>
    <file>
      <name>$PROJ_DIR$\source\custom_app\sap\persistent.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\source\custom_app\config.mk</name>
  </file>
  <file>
    <name>$PROJ_DIR$\source\custom_app\makefile</name>
  </file>
  <file>
    <name>$PROJ_DIR$\mcu\efr32xg13\hal\usart.c</name>
  </file>
</project>


