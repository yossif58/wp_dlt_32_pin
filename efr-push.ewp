# IAR project efr-push.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: efr-push.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    source/custom_app/: config.mk makefile
    mcu/efr32xg13/hal/: usart.c
  group drivers
    source/custom_app/drivers/: io.h led.h LICENSE.txt makefile
  group drivers/efr32xg13
    source/custom_app/drivers/efr32xg13/: exti.c exti.c.bak io.c io.c.bak led.c LICENSE.txt makefile
  group meter
    source/custom_app/: app.c
    board/brd4158a/: board.h
    source/custom_app/meter/: DCUPush.c DLTProtocol.c DLTProtocol.h gateway-passwords.c makefile MeterProtocol.c meterprotocol.h MeterPush.c persistent.c persistent.h uartdlt.c uartdlt.h Untitled1.c Untitled2 utils.c utils.h WaterCalc.h
  group sap
    source/custom_app/sap/: attribute_frames.h csap.c csap.h csap_frames.h dsap.c dsap.h dsap_frames.h function_codes.c function_codes.h LICENSE.txt lock_bits.c lock_bits.h msap.c msap.h msap_frames.h multicast.c multicast.h persistent.c persistent.c.bak persistent.h
